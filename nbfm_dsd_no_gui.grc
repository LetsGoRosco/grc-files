<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_bandwidth</value></param>
<param><key>value</key><value>12500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_offset</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_offset_fine</value></param>
<param><key>value</key><value>-800</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>adc_rate/decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_decim</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>adc_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>volume</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>squelch</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_interp</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>quad_rate</key><value>audio_rate*audio_interp</value></param>
<param><key>tau</key><value>75e-6</value></param>
<param><key>max_dev</key><value>5e3</value></param>
</block>
<block>
<key>dsd_block_ff</key>
<param><key>id</key><value>dsd_block_ff_1</value></param>
<param><key>frame</key><value>dsd.dsd_FRAME_AUTO_DETECT</value></param>
<param><key>mod</key><value>dsd.dsd_MOD_AUTO_SELECT</value></param>
<param><key>uvquality</key><value>3</value></param>
<param><key>errorbars</key><value>True</value></param>
<param><key>verbosity</key><value>2</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>interp</key><value>48000</value></param>
<param><key>decim</key><value>8000</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>volume</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_0</value></param>
<param><key>threshold</key><value>squelch*-1</value></param>
<param><key>alpha</key><value>1</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>audio_rate*audio_interp</value></param>
<param><key>decim</key><value>samp_rate/xlate_decim</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>442.574e6</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>gain0</key><value>50</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>xlate_decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, xlate_bandwidth/2, 1000)</value></param>
<param><key>center_freq</key><value>xlate_offset + xlate_offset_fine</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>nbfm_dsd_no_gui</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>dsd_block_ff_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dsd_block_ff_1</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_simple_squelch_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
